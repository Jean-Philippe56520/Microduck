# P15-B10: optional DEV-only selection of the already reviewed P15-B6 package.
# Keep OEM shipping image untouched; no service, model, permission or motor access.
IMAGE_INSTALL:append = " kwipi-passive-fixture"
